FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://ima.cfg"
